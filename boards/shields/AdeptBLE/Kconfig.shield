## boards/shields/AdeptBLE/Kconfig.shield
```kconfig
config SHIELD_ADEPTBLE_CENTRAL
    def_bool $(shields_list_contains,AdeptBLE_central)
    select ZMK_SPLIT_BLE_ROLE_CENTRAL
```
